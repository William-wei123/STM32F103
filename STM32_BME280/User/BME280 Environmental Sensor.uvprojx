# Keil uVision project BME280 Environmental Sensor.uvprojx, settings and files
target WavaShare (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BME280 Environmental Sensor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: ..\Application\BME280_application;..\Common;..\Common\delay;..\Drive\BME280_driver\selftest;..\Drive\BME280_driver;..\Drive\I2C_Soft;..\Drive\SPI_Hard;..\Libraries\STM32F10x_LIB\CMSIS;..\Libraries\STM32F10x_LIB\inc;..\User;..\SYSTEM;..\HEADWARE\ADC;..\HEADWARE\DEAL;..\HEADWARE\OLED;..\HEADWARE\PWM;..\HEADWARE\WIFI
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../Application/BME280_application/: bme280_application.c
  group Drive
    ../Drive/BME280_driver/: bme280.c
    ../Drive/BME280_driver/selftest/: bme280_selftest.c
    ../Drive/I2C_Soft/: i2c_soft.c
    ../Drive/SPI_Hard/: spi_hard.c
  group Library
    ../Libraries/STM32F10x_LIB/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
    ../Libraries/STM32F10x_LIB/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_spi.c
  group User
    ./: Config.c main.c stm32f10x_it.c
  group Common
    ../Common/delay/: delay.c
  group HARDWARE
    ../HEADWARE/ADC/: adc.c
    ../HEADWARE/WIFI/: MyWIFI.c
    ../HEADWARE/DEAL/: deal.c
    ../HEADWARE/OLED/: OLED.c
    ../HEADWARE/PWM/: pwm.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
